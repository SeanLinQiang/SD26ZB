# Keil uVision project SN32F700B_Demo.uvprojx, settings and files
target SN32700B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SN32F707BF SONiX
  pack: SONiX.SN32F7_DFP.1.4.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SN32F700B +hex
  AfterMake: hex2bin.exe -l 4000 -p 00 .\obj\SN32F700B.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Interface\CT;.\Interface\FLASH;.\Interface\GPIO;.\Interface\MCU_SDK;.\Interface\PMU;.\Interface\RTC;.\Interface\Source;.\Interface\SysTick;.\Interface\UART;.\Interface\WDT;.\System;.\Utility;.\RTE
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserApp
    ./: main.c
    ./Interface/Source/: userApp.c
  group System
    ./System/: SYS_con_drive.c
  group Utility
    ./Utility/: Utility.c
  group CT
    ./Interface/CT/: CT16B0.c CT16B1.c CT16B2.c
  group FLASH
    ./Interface/FLASH/: Flash.c
  group GPIO
    ./Interface/GPIO/: GPIO.c
  group PMU
    ./Interface/PMU/: PMU_drive.c
  group Systick
    ./Interface/SysTick/: SysTick.c
  group UART
    ./Interface/UART/: UART0.c UART1.c
  group WDT
    ./Interface/WDT/: WDT.c
  group MCU_SDK
    ./Interface/MCU_SDK/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.4
